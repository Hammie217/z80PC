.title KiCad schematic
U1 Net-_IC1-Pad23_ Net-_IC1-Pad2_ Net-_IC1-Pad26_ Net-_IC1-Pad1_ Net-_J4-Pad16_ clk Net-_IC1-Pad16_ Net-_IC1-Pad15_ Net-_IC1-Pad17_ Net-_IC1-Pad18_ 5V Net-_IC1-Pad13_ Net-_IC1-Pad19_ Net-_IC1-Pad11_ Net-_IC1-Pad12_ Net-_INT1-Pad2_ Net-_R11-Pad2_ HALT MREQ IORQ Net-_IC1-Pad22_ Net-_IC1-Pad27_ BUSACK Net-_R10-Pad2_ 5V Net-_R12-Pad2_ M1 RFSH gnd Net-_IC1-Pad10_ Net-_IC1-Pad9_ Net-_IC1-Pad8_ Net-_IC1-Pad7_ Net-_IC1-Pad6_ Net-_IC1-Pad5_ Net-_IC1-Pad4_ Net-_IC1-Pad3_ Net-_IC1-Pad25_ Net-_IC1-Pad24_ Net-_IC1-Pad21_ Z80CPU
IC1 Net-_IC1-Pad1_ Net-_IC1-Pad2_ Net-_IC1-Pad3_ Net-_IC1-Pad4_ Net-_IC1-Pad5_ Net-_IC1-Pad6_ Net-_IC1-Pad7_ Net-_IC1-Pad8_ Net-_IC1-Pad9_ Net-_IC1-Pad10_ Net-_IC1-Pad11_ Net-_IC1-Pad12_ Net-_IC1-Pad13_ gnd Net-_IC1-Pad15_ Net-_IC1-Pad16_ Net-_IC1-Pad17_ Net-_IC1-Pad18_ Net-_IC1-Pad19_ Net-_IC1-Pad20_ Net-_IC1-Pad21_ Net-_IC1-Pad22_ Net-_IC1-Pad23_ Net-_IC1-Pad24_ Net-_IC1-Pad25_ Net-_IC1-Pad26_ Net-_IC1-Pad27_ 5V 71256SA12TPG
R12 5V Net-_R12-Pad2_ 10k
J3 clk gnd Conn_01x02_Male
RESET1 gnd Net-_R12-Pad2_ SW1
R11 5V Net-_R11-Pad2_ 10k
SW1 gnd Net-_R11-Pad2_ sw2
R9 5V Net-_INT1-Pad2_ 10k
INT1 gnd Net-_INT1-Pad2_ sw2
R10 5V Net-_R10-Pad2_ 10k
WAIT1 gnd Net-_R10-Pad2_ sw2
M1 Net-_M1-Pad1_ M1 LED
RFSH1 Net-_R4-Pad2_ RFSH LED
HALT1 Net-_HALT1-Pad1_ HALT LED
MREQ1 Net-_MREQ1-Pad1_ MREQ LED
IORQ1 Net-_IORQ1-Pad1_ IORQ LED
R8 gnd Net-_BUSACK1-Pad1_ 10k
BUSACK1 Net-_BUSACK1-Pad1_ BUSACK LED
R7 gnd Net-_IORQ1-Pad1_ 10k
R6 gnd Net-_MREQ1-Pad1_ 10k
R5 gnd Net-_HALT1-Pad1_ 10k
R4 gnd Net-_R4-Pad2_ 10k
R3 gnd Net-_M1-Pad1_ 10k
U2 gnd Net-_J4-Pad16_ IORQ Net-_IC2-Pad20_ Net-_IC1-Pad20_ IO0-7 IO8-15 74LS139
IC2 Net-_IC1-Pad1_ Net-_IC1-Pad2_ Net-_IC1-Pad3_ Net-_IC1-Pad4_ Net-_IC1-Pad5_ Net-_IC1-Pad6_ Net-_IC1-Pad7_ Net-_IC1-Pad8_ Net-_IC1-Pad9_ Net-_IC1-Pad10_ Net-_IC1-Pad11_ Net-_IC1-Pad12_ Net-_IC1-Pad13_ gnd Net-_IC1-Pad15_ Net-_IC1-Pad16_ Net-_IC1-Pad17_ Net-_IC1-Pad18_ Net-_IC1-Pad19_ Net-_IC2-Pad20_ Net-_IC1-Pad21_ Net-_IC1-Pad22_ Net-_IC1-Pad23_ Net-_IC1-Pad24_ Net-_IC1-Pad25_ Net-_IC1-Pad26_ NC_01 5V AT28C64B-15PU
J4 Net-_IC1-Pad10_ Net-_IC1-Pad9_ Net-_IC1-Pad8_ Net-_IC1-Pad7_ Net-_IC1-Pad6_ Net-_IC1-Pad5_ Net-_IC1-Pad4_ Net-_IC1-Pad3_ Net-_IC1-Pad25_ Net-_IC1-Pad24_ Net-_IC1-Pad21_ Net-_IC1-Pad23_ Net-_IC1-Pad2_ Net-_IC1-Pad26_ Net-_IC1-Pad1_ Net-_J4-Pad16_ Conn_02x08_Top_Bottom
IO0-1 Net-_IO0-1-Pad1_ IO0-7 LED
R2 gnd Net-_IO0-1-Pad1_ 10k
IO8-1 Net-_IO8-1-Pad1_ IO8-15 LED
R1 gnd Net-_IO8-1-Pad1_ 10k
J2 5V NC_02 NC_03 Net-_J2-Pad4_ Net-_J2-Pad4_ USB_A
J1 5V NC_04 NC_05 NC_06 Net-_J1-Pad5_ Net-_J1-Pad5_ USB_B_Mini
.end
